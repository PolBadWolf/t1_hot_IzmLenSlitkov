# IAR project Izmeritel.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x60
  General.SCRStackSize: 48
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x400
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  XLINK.XExtraOptions: -we133=i; -Ointel-extended,(CODE)=Debug\Exe\prog.hex; -Ointel-extended,(XDATA)=Debug\Exe\eeprom.hex
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  General.LCNearHeapSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: dac_ad420.cpp izm_len1.cpp main.cpp menu.cpp Object.cpp OutDebug.cpp UserTimer.cpp Variable.cpp
  group system
    system/: clock.cpp crc.cpp DisplayTimer.cpp InitSystem.cpp key4.cpp lcd.cpp ports.cpp ports1.cpp rs232.cpp rs485.cpp SystemTimerUser.cpp watchdog.cpp
