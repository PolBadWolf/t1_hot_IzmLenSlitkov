# IAR project Imitator.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x40
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x200
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  XLINK.XExtraOptions: -we133=i; -Ointel-extended,(CODE)=Debug\Exe\prog.hex; -Ointel-extended,(XDATA)=Debug\Exe\eeprom.hex
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  General.LCNearHeapSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: dac_ad420.cpp ImitWorkSlitok.cpp main.cpp menu.cpp Object.cpp ReadDat.cpp UserTimer.cpp Variable.cpp
  group system
    system/: clock.cpp crc.cpp DisplayTimer.cpp InitSystem.cpp key4.cpp lcd.cpp moduls.cpp ports.cpp rs232.cpp rs485.cpp SystemTimerUser.cpp
